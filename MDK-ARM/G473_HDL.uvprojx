# Keil uVision project G473_HDL.uvprojx, settings and files
target G473_HDL (6190000::V6.19::.\ArmCompilerforEmbedded6.19)
  device: STM32G473CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: G473_HDL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G473xx,ULOG_ENABLED
  c include: ../Core/Inc;../USB_Device/App;../USB_Device/Target;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../BFL/ulog/src;../BFL;../HDL;../LIB;../freemodbus/include;../freemodbus/functions;../freemodbus/port;../freemodbus/rtu;../Ethernet;../Ethernet/W5500;../Ethernet/Application;../freemodbus/tcp;../Measure;../Board;../APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group HDL
    ../HDL/: HDL_G4_Uart.c HDL_G4_Uart_test.c HDL_G4_CPU_Time.c HDL_G4_CPU_Time_test.c
  group BFL
    ../BFL/: log.c CHIP_MIZ043WO1RPGA.c asyn_sys.c BFL_LED.c CHIP_TTL_Screen.c CHIP_TCA9548A.c CHIP_MCP4017T_104.c CHIP_TMP102.c tmp102.c
    ../BFL/ulog/src/: ulog.c
  group freemodbus
    ../freemodbus/: mb.c
    ../freemodbus/rtu/: mbcrc.c mbrtu.c
    ../freemodbus/port/: mbcb.c portevent.c portserial.c porttimer.c porttcp.c
    ../freemodbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../freemodbus/tcp/: mbtcp.c
  group Ethernet
    ../Ethernet/: socket.c wizchip_conf.c
    ../Ethernet/W5500/: w5500.c
  group APP
    ../Ethernet/Application/: dhcp.c dns.c
    ../APP/: APP_Ethernet.c APP_Modbus_Slaver.c APP_Main.c SysMeasure.c
  group Board
    ../Board/: board.c
  group LIB
    ../LIB/: circular_array_queu.c circular_array_queu_test.c crc.c modbus_host.c modbus_test.c mQueue.c mytime.c sc_byte_buffer.c sc_list.c test.c average_filter.c kalman_filter.c
software components: CMSIS:CORE 5.6.0
